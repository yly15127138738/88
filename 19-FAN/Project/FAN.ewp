# IAR project FAN.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\Source
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../Source/: readme.txt
  group Source
    ../Source/: clock.c delay.c fan.c key.c led.c main.c uart1.c
    E:/xLabGreenHouse/02-实验项目/01-单片机与传感器实验/实验习题/04-Timer/Source/: timer.c
